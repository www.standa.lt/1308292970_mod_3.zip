# Autodesk Inventor part: 4LM13-40internetui
## iProperties
Created: 2010-02
Part Number: 4LM13-40internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
